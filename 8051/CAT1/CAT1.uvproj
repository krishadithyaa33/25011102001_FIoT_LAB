# Keil uVision project CAT1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  output: CAT1 +hex
  group Source Group 1
    ./: STARTUP.A51 main.c
